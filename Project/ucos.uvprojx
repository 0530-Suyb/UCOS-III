# Keil uVision project ucos.uvprojx, settings and files
target ucos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ucos
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c include: ..\User;..\User\uCOS-III;..\User\uCOS-CPU;..\User\uCOS-LIB;..\User\uCOS-III\Ports;..\User\uCOS-III\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: app.c
  group μC/OS-III Source
    ../User/uCOS-III/Source/: os.h os_cfg.h os_core.c os_task.c os_type.h os_var.c os_time.c os_cfg_app.c os_cfg_app.h
  group μC/OS-III Ports
    ../User/uCOS-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group μC/CPU
    ../User/uCOS-CPU/: cpu.h cpu_a.asm
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
